# Keil uVision project GD32330K_START.uvproj, settings and files
target GD32F330K_START (ARM-ADS)
  device: GD32F330K8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF)IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F330
  c include: ..\..\02_GPIO_Key_Polling_mode;..\..\..\Utilities;..\..\..\..\GD32F3x0_Firmware_Library\CMSIS;..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include;..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: main.c gd32f3x0_it.c systick.c
  group CMSIS
    ../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group GD32F3x0_Peripherals
    ../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group GD32F3x0_START
    ../../../Utilities/: gd32f330k_start.c
  group Startup
    ../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Doc
    ../: readme.txt
