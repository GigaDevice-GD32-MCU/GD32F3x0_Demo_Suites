# Keil uVision project GD32F310C_EVAL.uvproj, settings and files
target GD32F310C_EVAL (ARM-ADS)
  device: GD32F310C8 GigaDevice
  cpu: IRAM(0x20000000-0x20000FFF)IROM(0x08000000-0x08003FFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: GD32310C_EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F310
  c include: ..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include;..\..\..\..\GD32F3x0_Firmware_Library\CMSIS;..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include;..\..\..\Utilities;..\Soft_Drive;..\..\07_ADC_conversion_triggered_by_timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application
    ../: main.c gd32f3x0_it.c systick.c
  group CMSIS
    ../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group GD32F3x0_Peripherals
    ../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group GD32F3x0_EVAL
    ../../../Utilities/: gd32f310c_eval.c
  group Soft_Drive
    ../Soft_Drive/: gui.c lcd_driver.c
  group Startup
    ../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Doc
    ../: readme.txt
